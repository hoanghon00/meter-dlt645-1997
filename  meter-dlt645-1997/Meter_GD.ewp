# IAR project Meter_GD.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 512
  General.GFarHeapSize: 1024
  General.GeneralDeviceSelect: 78F1166_A0 78K0R - uPD78F1166_A0
  ICC78000.CCIncludePath2: $PROJ_DIR$; uOS\SRC\; uOS\PORT\78K\; APP\Cfg\H; APP\TASK; APP\HUCK\Energy\H; APP\HUCK\LoadData\H; APP\HUCK\Monitor\H; APP\HUCK\Clock\H; APP\HUCK\Control\H; APP\HUCK\Extend\H; APP\Main\H; APP\HUCK\Protocol\H; APP\HUCK\VolStat\H; APP\HUCK\EventData\H; APP\HUCK\LowPower\H; APP\Pub\H; APP\HUCK\Storage\H; APP\PUCK\Private\MeasuProc\h; APP\PUCK\Private\Alarm; APP\PUCK\Private\ICcard; APP\PUCK\Private\EventProc\h; APP\PUCK\Private\Channel\h; APP\PUCK\Private\Remoter; APP\LUCK\h; APP\PUCK\Public\h; ABS\PUCK\; DRV\QUCK\; DRV\PUB\; DRV\SUCK\; DRV\PUCK\LCD; DRV\PUCK\ICCARD; DRV\PUCK\IIC; DRV\PUCK\LVI; DRV\PUCK\WDT; DRV\PUCK\RTC; DRV\PUCK\UART; TEST\HUCK\UnitTest\H; TEST\HUCK\FuncTest\H; TEST\TestPub\H; TEST\PUCK\DRV_TEST
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 2
  ICC78000.CCOptStrategy: 0
  A78000.ADefines: __FAR_MODEL__; __FAR_DATA_MODEL__
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk78f1166_a0.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  General.GFarHeapSize: 4096
  ICC78000.CCIncludePath2: $PROJ_DIR$; uOS\SRC\; uOS\PORT\78K\; APP\Cfg\H; APP\TASK; APP\HUCK\Energy\H; APP\HUCK\LoadData\H; APP\HUCK\Monitor\H; APP\HUCK\Clock\H; APP\HUCK\Control\H; APP\Main\H; APP\HUCK\Protocol\H; APP\HUCK\VolStat\H; APP\HUCK\EventData\H; APP\HUCK\LowPower\H; APP\Pub\H; APP\HUCK\Storage\H; APP\PUCK\Private\MeasuProc\h; APP\PUCK\Private\Alarm; APP\PUCK\Private\EventProc\h; APP\PUCK\Private\Channel\h; APP\PUCK\Private\Remoter; APP\LUCK\h; APP\PUCK\Public\h; ABS\PUCK\; DRV\QUCK\; DRV\PUB\; DRV\SUCK\; DRV\PUCK\LCD; DRV\PUCK\IIC; DRV\PUCK\LVI; DRV\PUCK\WDT; DRV\PUCK\RTC; DRV\PUCK\UART; TEST\HUCK\UnitTest\H; TEST\HUCK\FuncTest\H; TEST\TestPub\H; TEST\PUCK\DRV_TEST
  ICC78000.CCOptLevel: 3
  ICC78000.CCOptStrategy: 1
  XLINK.XclFile: md_lnk78f1166_a0.xcl
  group ABS/PUCK/Private
    ABS/PUCK/: DeviceAbs.c DeviceAbs.h InterrAbs.c InterrAbs.h MemoryAbs.c MemoryAbs.h PortAbs.c PortAbs.h RTCAbs.c RTCAbs.h UartAbs.c UartAbs.h
  group APP/CFG
    APP/Cfg/H/: Meter_Cfg.h
  group APP/HUCK/CLOCK
    APP/HUCK/Clock/C/: Clock.c
    APP/HUCK/Clock/H/: Clock.h
  group APP/HUCK/CONTROL
    APP/HUCK/Control/C/: Power_Ctrl.c
    APP/HUCK/Control/H/: Power_Ctrl.h
  group APP/HUCK/ENERGE
    APP/HUCK/Energy/C/: Demand.c Energy.c
    APP/HUCK/Energy/H/: Demand.h Energy.h
  group APP/HUCK/EVENTDATA
    APP/HUCK/EventData/C/: Event_Cumu.C Event_Data.c Event_MultiTimes.C
    APP/HUCK/EventData/H/: Event_Cumu.h Event_Data.h Event_MultiTimes.h
  group APP/HUCK/EXTEND
    APP/HUCK/Extend/C/: Extend.c Extend_GD.c
    APP/HUCK/Extend/H/: Extend.h Extend_GD.h Extend_GD_Def_Para.h
  group APP/HUCK/LOADDATA
    APP/HUCK/LoadData/C/: Freeze_Data.c Load_Data.c
    APP/HUCK/LoadData/H/: Freeze_Data.h Load_Data.h
  group APP/HUCK/LOWPOWER
    APP/HUCK/LowPower/C/: Low_Power.c
    APP/HUCK/LowPower/H/: Low_Power.h
  group APP/HUCK/MONITOR
    APP/HUCK/Monitor/C/: Monitor.c
    APP/HUCK/Monitor/H/: Monitor.h
  group APP/HUCK/PROTOCOL
    APP/HUCK/Protocol/C/: Authority.c Data_Spec.c Data_Trans.c
    APP/HUCK/Protocol/H/: Authority.h Data_Spec.h Data_Trans.h
  group APP/HUCK/STORAGE
    APP/HUCK/Storage/C/: Data_Para.c Def_Para.c HIS_Data.c Memory.c
    APP/HUCK/Storage/H/: Data_Para.h Def_Para.h HIS_Data.h Mem_Cfg.h Memory.h
  group APP/HUCK/VOLSTAT
    APP/HUCK/VolStat/C/: VolStat.c
    APP/HUCK/VolStat/H/: VolStat.h
  group APP/LUCK
    APP/LUCK/H/: config.h interface.h Lcd_main_LUCK.h process.h support.h
    APP/LUCK/C/: interface.c interface_JS_ZXW.c Lcd_main_LUCK.c process.c support.c
  group APP/MAIN
    APP/Main/C/: Main_Proc.c
  group APP/PUB
    APP/Pub/H/: Includes.h Pub.h Pub_Debug.h Pub_Err.h Pub_Sem.h Pub_Time.h
    APP/Pub/C/: Pub.c Pub_Debug.c Pub_Time.c
  group APP/PUCK/PRIVATE/Alarm
    APP/PUCK/Private/Alarm/: Alarm.c Alarm.h
  group APP/PUCK/PRIVATE/CHANNEL
    APP/PUCK/Private/Channel/c/: Channel.c
    APP/PUCK/Private/Channel/h/: Channel.h
  group APP/PUCK/PRIVATE/EVENT
    APP/PUCK/Private/EventProc/c/: EventInstant.c EventPub.c EventStatus.c
    APP/PUCK/Private/EventProc/h/: EventInstant.h EventPub.h EventStatus.h
  group APP/PUCK/PRIVATE/IC_CARD
    APP/PUCK/Private/ICcard/: ICcardApp.c ICcardApp.h
  group APP/PUCK/PRIVATE/MEASURE
    APP/PUCK/Private/MeasuProc/c/: MeasuBase.c MeasuLib.c MeasuPara.c MeasuPort.c MeasuProc.c MeasuPulse.c
    APP/PUCK/Private/MeasuProc/h/: MeasuBase.h MeasuLib.h MeasuPara.h MeasuPort.h MeasuProc.h MeasuPulse.h
  group APP/PUCK/PRIVATE/REMOTER
    APP/PUCK/Private/Remoter/: Remoter.c Remoter.h
  group APP/PUCK/PUBLIC
    APP/PUCK/Public/H/: App_Cfg_PUCK.h Include_PUCK.h Pub_Puck.h
    APP/PUCK/Public/C/: Pub_PUCK.c
  group APP/TASK
    APP/TASK/: TaskProc.c TaskProc.h
  group DRV/PUB
    DRV/PUB/: CPUPub.c CPUPub.h DrvCfg.h DrvPub.c DrvPub.h
  group DRV/PUCK/ICcard
    DRV/PUCK/ICCARD/: ICcardDrv.c ICcardDrv.h
  group DRV/PUCK/IIC/APP
    DRV/PUCK/IIC/: App_Epp_All.c App_Epp_All.h DS3231_Soft.c DS3231_Soft.h
  group DRV/PUCK/IIC/CPU
    DRV/PUCK/IIC/: I2C_Soft.c I2C_Soft.h IIC0_Hard.c IIC0_Hard.h
  group DRV/PUCK/IIC/DRV
    DRV/PUCK/IIC/: DS3231_Hard.c DS3231_Hard.h Epp_Hard.c Epp_Hard.h Epp_Soft.c Epp_Soft.h
  group DRV/PUCK/LCD
    DRV/PUCK/LCD/: APP_LCD_Pub.h APP_LCD_Pub_JS_ZXW.h HTLCD_LIB.C HTLCD_LIB.h HTLCD_LIB_JS_ZXW.h HTLCD_SPI.C HTLCD_SPI.h LCD_CFG.h
  group DRV/PUCK/LVI
    DRV/PUCK/LVI/: LVI.c LVI.h
  group DRV/PUCK/RTC
    DRV/PUCK/RTC/: RTC.c RTC.h RTC_user.c
  group DRV/PUCK/UART
    DRV/PUCK/UART/: Serial.c Serial.h Serial_user.c
  group DRV/PUCK/WDT
    DRV/PUCK/WDT/: WatchdogTimer.c WatchdogTimer.h WatchdogTimer_user.c
  group DRV/SUCK
    DRV/SUCK/: data_flash.c data_flash.h Int.c Int.h Int_user.c macrodriver.h pindef.h Port.c port.h System.c System.h System_user.c systeminit.c TAU.c TAU.h TAU_user.c user_define.h
  group TEST/HUCK/FUNCTEST
    TEST/HUCK/FuncTest/C/: Test_Event_Data.c
    TEST/HUCK/FuncTest/H/: Test_Event_Data.H
  group TEST/PUCK/DRV_TEST
    TEST/PUCK/DRV_TEST/: DRV_TEST.c DRV_TEST.h
  group TEST/TESTPUB
    TEST/TestPub/C/: Test_Pub.c Test_Stub.c
    TEST/TestPub/H/: Test_Pub.h
  group UOS/PORT
    UOS/PORT/78K/: OS_Port.c OS_Port.h
  group UOS/SRC
    UOS/SRC/: OS_Cfg.h OS_Core.c OS_Core.h OS_Ext.c OS_Ext.h OS_Pub.c OS_Pub.h OS_Sem.c OS_Sem.h
